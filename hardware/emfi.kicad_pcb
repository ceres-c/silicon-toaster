# Repository ceres-c/silicon-toaster

## KiCad design hardware/emfi.kicad_pcb

Parts:
C1, C42: 100n; C_0603_1608Metric; Voltage 25; LCSC C36911393
J1: USB_B_Micro; USB_Micro-B_Wuerth_629105150521; LCSC C2894326
J2, J3, J6: Conn_Coaxial; SAMTEC_SMA_J_P_H_ST_EM3; LCSC C3175374
L1: Ferrite_Bead_Small; L_0603_1608Metric; LCSC C85834
LOGO1: DUNGEON_LOGO; donjon-2000
R7: 10k; R_0603_1608Metric; LCSC C2792070
U8: 74LVC1G32; SOT-353_SC-70-5; LCSC C12516

Connections:
+3V3: C42.2, U8.5 (VCC); also elsewhere on the board
+5V: L1.2; also elsewhere on the board
/VBUS: C1.2, J1.1 (VBUS), L1.1
/analog/ANTENNA_A: J3.1 (In), J6.2 (Ext); also elsewhere on the board
/analog/ANTENNA_B: J3.2 (Ext), J6.1 (In); also elsewhere on the board
/analog/SHOOT: U8.4; also elsewhere on the board
/ft232/USBD+: J1.3 (D+); also elsewhere on the board
/ft232/USBD-: J1.2 (D-); also elsewhere on the board
/mcu/SW_SHOOT: U8.1; also elsewhere on the board
GND: C1.1, C42.1, J1.5 (GND), J1.6 (Shield), J2.2 (Ext), R7.2, U8.3 (GND); also elsewhere on the board
unnamed: J2.1 (In), R7.1, U8.2

Notes on the sheet:
Positive pulse to shoot
Injection probe connectors

Parts:
C9: 100n; C_0603_1608Metric; Voltage 25; LCSC C36911393
U2: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm; LCSC C8690

Connections:
+3V3: U2.4 (VCCIO), U2.20 (VCC); also elsewhere on the board
/ft232/RX: U2.5 (RXD); also elsewhere on the board
/ft232/USBD+: U2.15 (USBD+); also elsewhere on the board
/ft232/USBD-: U2.16 (USBD-); also elsewhere on the board
/mcu/RX: U2.1 (TXD); also elsewhere on the board
GND: C9.2, U2.7 (GND), U2.18 (GND), U2.21 (GND), U2.25 (AGND), U2.26 (TEST); also elsewhere on the board
unnamed: C9.1, U2.17 (3V3OUT)

Parts:
C2, C3, C4, C5, C8, C17: 100n; C_0603_1608Metric; Voltage 25; LCSC C36911393
C6, C7: 2.2µ; C_0603_1608Metric; Voltage 25; LCSC C36911393
D7: red; D_0603_1608Metric; LCSC C598355
D8: green; D_0603_1608Metric; LCSC C5875725
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R1, R4: 10k; R_0603_1608Metric; LCSC C2792070
R8, R10: 64.9; R_0603_1608Metric; LCSC C228008
U1: STM32F205RETx; LQFP-64_10x10mm_P0.5mm; LCSC C66278

Connections:
+3V3: C2.1, C3.1, C4.1, C5.1, C8.1, C17.1, J4.2, U1.1 (VBAT), U1.7 (NRST), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD); also elsewhere on the board
/analog/CHARGE_PWM: U1.41 (PA8); also elsewhere on the board
/ft232/RX: U1.42 (PA9); also elsewhere on the board
/mcu/20V_EN: R1.2, U1.30 (PB11); also elsewhere on the board
/mcu/ADC: U1.14 (PA0); also elsewhere on the board
/mcu/RX: U1.43 (PA10); also elsewhere on the board
/mcu/SW_SHOOT: U1.46 (PA13); also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C17.2, D7.1 (K), D8.1 (K), R1.1, R4.1, U1.12 (VSSA), U1.18 (VSS), U1.28 (PB2), U1.63 (VSS); also elsewhere on the board
unnamed: C6.1, U1.31 (VCAP_1)
unnamed: C7.1, U1.47 (VCAP_2)
unnamed: D7.2 (A), R8.1
unnamed: D8.2 (A), R10.1
unnamed: J4.1, R4.2, U1.60 (BOOT0)
unnamed: R8.2, U1.2 (PC13)
unnamed: R10.2, U1.3 (PC14)

Notes on the sheet:
Short to enable ST bootloader

Parts:
C10, C11, C12, C13, C14: 2.2µ; C_0603_1608Metric; Voltage 25; LCSC C36911393
C15: 22u; C_0805_2012Metric; Voltage 25; LCSC C6119899
C16: 100n; C_0603_1608Metric; Voltage 25; LCSC C36911393
D5: MBRM140T3; D_Powermite_AK; LCSC C145540
L2: 10µ; L_1812_4532Metric; LCSC C98022
R5: 22.1k; R_0603_1608Metric; LCSC C137768
R6: 2k; R_0603_1608Metric; LCSC C103390
U3: MIC2288; SOT-23-5; LCSC C220754
U4, U5: LD1117S33TR_SOT223; SOT-223-3_TabPin2; LCSC C86781

Connections:
+3V3: C14.1, U5.2 (VO); also elsewhere on the board
+3V3A: C13.1, U4.2 (VO); also elsewhere on the board
+5V: C10.1, C11.1, C12.1, L2.1, U3.5 (VIN), U4.3 (VI), U5.3 (VI); also elsewhere on the board
+15V: C15.1, C16.2, D5.1 (K), R5.1; also elsewhere on the board
/mcu/20V_EN: U3.4 (EN); also elsewhere on the board
GND: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, R6.2, U3.2 (GND), U4.1 (GND), U5.1 (GND); also elsewhere on the board
unnamed: D5.2 (A), L2.2, U3.1 (SW)
unnamed: R5.2, R6.1, U3.3 (FB)

Notes on the sheet:
330 µC
Vout = 1.24 x (R5/R6 + 1) R6 <= 5k

Parts:
C18, C19, C20, C21: 150n; C_2225_5664Metric_Pad1.80x6.60mm_HandSolder; Voltage 1000; LCSC C20613286
D1, D2, D3, D4, D6, D9: US1K-E3/61T; D_SMA_Handsoldering; LCSC C3013866
J5: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
Q1: STT6N3LLH6; SOT-23-6; LCSC C457495
Q2: IKW40N120H3FKSA1; TO-247-3_Horizontal_TabDown_NoTabDrill; LCSC C3199294
R2, R11: 10M; R_0603_1608Metric; LCSC C101257
R3: 10k; R_0603_1608Metric; LCSC C2792070
R9: 4.99; R_0603_1608Metric; LCSC C137704
U6: MCP1407-E/SN; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C52138
U7: SCS-200LD; SCS-200L

Connections:
+3V3A: J5.3; also elsewhere on the board
+15V: J5.1, U6.1 (VDD), U6.8 (VDD); also elsewhere on the board
/analog/ANTENNA_A: D6.1 (K), D9.1 (K), R2.1; also elsewhere on the board
/analog/ANTENNA_B: D9.2 (A), Q2.2 (C); also elsewhere on the board
/analog/CHARGE_PWM: Q1.3, R11.1; also elsewhere on the board
/analog/SHOOT: U6.2 (INPUT); also elsewhere on the board
/mcu/ADC: R2.2, R3.1; also elsewhere on the board
GND: C19.1, D1.2 (A), Q1.4, Q2.3 (E), R3.2, R11.2, U6.4 (GND), U6.5 (GND), U7.5; also elsewhere on the board
unnamed: C18.1, C20.2, D1.1 (K), D2.2 (A)
unnamed: C18.2, U7.6
unnamed: C19.2, C21.2, D2.1 (K), D3.2 (A)
unnamed: C20.1, D3.1 (K), D4.2 (A)
unnamed: C21.1, D4.1 (K), D6.2 (A)
unnamed: J5.2, U7.2, U7.4
unnamed: Q1.1, Q1.2, Q1.5, Q1.6, U7.1, U7.3
unnamed: Q2.1 (G), R9.1
unnamed: R9.2, U6.6 (OUT), U6.7 (OUT)

Notes on the sheet:
10x ceramic capacitors
Gate charge = 185 nC VGE = 15 V C = 1 nF
If the gate if floating when not driven by the MCU (for example when reprogramming the device), it may charge overtime... A high impedance pull-down may help.
For the routing of this sheet, there must be enough insulation between high-voltage tracks and other signals to prevent air electrical breakdown (3 kV / mm) For the same reason, the PCB thickness must be > 1mm
1000 V rated capacitors
Bridge to adapt voltage to ADC input range. Also acts a bleeding resistors for safety.

Parts:
C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41: 100n; C_2225_5664Metric_Pad1.80x6.60mm_HandSolder; Voltage 1500; LCSC C1021531

Connections:
/analog/ANTENNA_A: C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2; also elsewhere on the board
GND: C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1; also elsewhere on the board

Board: 2 copper layers, 132.5 x 38.0 mm, 81 parts (18 on the bottom side), 37 nets.

## Commit log

2025-01-18 Added kicad-jlcpcb-tools compatible lcsc parts (tentative)
2025-01-18 jlcpcb gerber/bom/cpl (tentative)
2025-03-08 Updated sheet numbers + annotatios to embed in other project
2025-05-09 Project update
2025-05-09 Updated JLCPCB parts - generated production files
